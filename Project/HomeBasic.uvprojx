# Keil uVision project HomeBasic.uvprojx, settings and files
target HomeBasic_Debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HomeBasic +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,OS_UCOS
  c include: ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Utilities\debug;..\Project;..\Utilities\stm32_eval;..\drivers\stm32f10x\inc;..\kernel\ucos\include;..\kernel\api\inc;..\app;..\Libraries\FATFS\src;..\Libraries\FATFS\exfuns;..\Libraries\USB\STM32_USB-FS-Device_Driver\inc;..\Libraries\USB\CONFIG
  memory RVCT1: ROM 0x64000000 size 0x200000
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md_vl.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group os
    ../kernel/ucos/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../kernel/ucos/uCOS-II/Ports/ARM-Cortex-M3/IAR/: os_cpu_c.c os_cpu_a.asm
  group os_api
    ../kernel/api/src/: atomic.c memory.c task.c
  group Drivers
    ../xrf_lib/: xrf_lib_ucos2.lib
  group STM32_EVAL
    ../Utilities/stm32_eval/: stm32_eval.h stm32_eval.c stm32_timer.c stm32_key.c stm32_fsmc_nor_flash.c stm32_uart.c stm32_fsmc_sram.c stm32_fsmc_nand.c w25qxx.c spi.c sdcard.c msd.c
  group Fatfs
    ../Libraries/FATFS/src/: diskio.c ff.c
  group User
    ../Utilities/debug/: debug.h
    ../app/: main.cpp
    ./: stm32f10x_it.c
  group app
    ../app/: my_platform.c app_cfg.h app.cpp
  group Doc
    ./: readme.txt
    ../: C++头文件模板.txt
  group USB_Core
    ../Libraries/USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_Config
    ../Libraries/USB/CONFIG/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
software components: CMSIS:CORE 4.1.0
